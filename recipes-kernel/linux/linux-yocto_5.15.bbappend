require linux-yocto-nxp-imx6.inc

KBRANCH:nxp-imx6  = "v5.15/standard/nxp-sdk-5.15/nxp-soc"
