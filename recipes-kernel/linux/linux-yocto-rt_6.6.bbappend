require linux-yocto-nxp-imx6.inc

KBRANCH:nxp-imx6  = "v6.6/standard/preempt-rt/nxp-sdk-6.6/nxp-soc"
