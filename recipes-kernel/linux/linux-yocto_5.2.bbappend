require linux-yocto-nxp-imx6.inc

KBRANCH_nxp-imx6 = "v5.2/standard/nxp-imx/sdk-4.19.35/nxp-imx6"
