require linux-yocto-nxp-imx6.inc

KBRANCH_nxp-imx6 = "v5.10/standard/preempt-rt/nxp-sdk-5.10/nxp-soc"
