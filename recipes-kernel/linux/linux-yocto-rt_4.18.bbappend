require linux-yocto-nxp-imx6.inc

KBRANCH_nxp-imx6 = "standard/preempt-rt/nxp-imx/sdk-4.14.78/nxp-imx6"
