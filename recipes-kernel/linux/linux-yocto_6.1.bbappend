require linux-yocto-nxp-imx6.inc

KBRANCH:nxp-imx6  = "v6.1/standard/nxp-sdk-6.1/nxp-soc"
