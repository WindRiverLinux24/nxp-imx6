require linux-yocto-nxp-imx6.inc

KBRANCH:nxp-imx6  = "v6.6/standard/nxp-sdk-6.6/nxp-soc"
