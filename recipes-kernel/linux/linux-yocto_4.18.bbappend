require linux-yocto-nxp-imx6.inc

KBRANCH_nxp-imx6 = "v4.18/standard/nxp-imx/sdk-4.14.78/nxp-imx6"
