include do_make_nxp_imx6_wic.inc
